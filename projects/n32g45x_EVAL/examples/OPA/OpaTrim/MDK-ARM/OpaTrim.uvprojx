# Keil uVision project OpaTrim.uvprojx, settings and files
target N32G45x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G457QEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.1.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OpaTrim
  AfterMake: fromelf --bin --output=.\bin\OpaTrim.bin .\Objects\OpaTrim.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g45x_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g45x.c
  group FWLB
    ../../../../../../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_adc.c n32g45x_dac.c n32g45x_dma.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_rcc.c n32g45x_tim.c n32g45x_usart.c n32g45x_opamp.c
  group USER
    ../src/: main.c n32g45x_it.c
  group BSP
    ../../../../bsp/src/: delay.c log.c
  group DOC
    ../: readme.txt
